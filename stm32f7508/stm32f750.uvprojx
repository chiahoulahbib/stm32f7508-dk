# Keil uVision project stm32f750.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F750N8Hx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x10000) IROM2(0x00200000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: stm32f750 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group User Application
    ./: main.c
  group User Libraries
    ./: stm32f7xx_HAL_GPIO.c stm32f7xx_HAL_GPIO.h stm32f7xx_HAL_RCC.h stm32f7xx_HAL_RCC.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.5
